# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\Source\STM32F103\CMSIS;..\..\Source\STM32F103\Core;..\..\Source\STM32F103\Library\inc;..\..\Source\STM32F103\Startup;..\..\Source\STM32F103\STM32F10x;..\..\Source\DeviceLib;.;..\..\Source\DeviceLib\MPU6050;..\..\Source\DeviceLib\MPU6050\Algorithm;..\..\Source\DeviceLib\MPU6050\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: main.c
  group STM32F103/STM32F10x
    ../../Source/STM32F103/STM32F10x/: stm32f10x_it.c system_stm32f10x.c
  group STM32F103/CMSIS
    ../../Source/STM32F103/CMSIS/: core_cm3.c
  group STM32F103/Startup
    ../../Source/STM32F103/Startup/: startup_stm32f10x_md.s
  group STM32F103/Core
    ../../Source/STM32F103/Core/: bsp_adc.c bsp_dac.c bsp_delay.c bsp_dma.c bsp_exti.c bsp_iic.c bsp_key.c bsp_led.c bsp_spi.c bsp_sys.c bsp_timer_advance.c bsp_timer_basic.c bsp_timer_general.c bsp_usart.c bsp_soft_i2c.c
  group STM32F103/Library
    ../../Source/STM32F103/Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DeviceLib/MPU6050
    ../../Source/DeviceLib/MPU6050/: mpu6050.c control.c
    ../../Source/DeviceLib/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c inv_mpu_stm32port.c
    ../../Source/DeviceLib/MPU6050/Algorithm/: FirstOrderLowPassFilter.c KalmanFilter.c MadgwickAHRS.c MahonyAHRS.c
